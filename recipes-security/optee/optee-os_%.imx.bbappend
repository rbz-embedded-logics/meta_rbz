FILESEXTRAPATHS:prepend := "${THISDIR}/optee-os:"
SRC_URI:append = " file://0001-changes-for-rbz-modules.patch"
