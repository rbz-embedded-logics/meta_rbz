FILESEXTRAPATHS_prepend := "${THISDIR}/alsa-state:"

SRC_URI_append = " file://asound.state"
