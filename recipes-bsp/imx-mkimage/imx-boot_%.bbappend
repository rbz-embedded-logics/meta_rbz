FILESEXTRAPATHS_prepend := "${THISDIR}/imx-boot:"
SRC_URI_append = " file://0001-Add-MOD_IMX8M_PLUS-support.patch"
