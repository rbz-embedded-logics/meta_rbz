FILESEXTRAPATHS:prepend := "${THISDIR}/imx-atf:"
SRC_URI:append = " file://0001-Add-MOD_IMX8M_PLUS-support.patch"
SRC_URI:append = " file://0002-Add-MOD_IMX8M_NANO-support.patch"
SRC_URI:append = " file://0003-Add-MOD_IMX8M_MINI-support.patch"
